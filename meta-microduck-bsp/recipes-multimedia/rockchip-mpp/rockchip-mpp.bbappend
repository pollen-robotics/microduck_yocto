# Our gstreamer-rockchip needs MPP's MppSysCfg API, which meta-rockchip's b29e4b7
# lacks. SRCREV is enough (nobranch=1). Drop when meta-rockchip moves both pins.

SRCREV:microduck-machine = "c5b8620973c7e22224fcc78ad5016740979c2e0a"
